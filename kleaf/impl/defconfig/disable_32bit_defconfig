## kleaf/impl/defconfig/disable_32bit_defconfig
```kconfig
# CONFIG_COMPAT is not set
# CONFIG_COMPAT_32BIT_TIME is not set
CONFIG_DEFAULT_MMAP_MIN_ADDR=65536
CONFIG_LSM_MMAP_MIN_ADDR=65536
```
